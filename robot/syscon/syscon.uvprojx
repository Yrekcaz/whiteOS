# Keil uVision project syscon.uvprojx, settings and files
target syscon (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: syscon +hex
  AfterMake: python ./tools/sign.py -k ./tools/victorSysConSigningKeyPvt.pem -b build/syscon.dfu build/syscon/syscon.axf
  AfterMake: fromelf --bin build/syscon/syscon.axf --output build/syscon_raw.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030X8
  c misc: --gnu
  c include: src;common;schema;build
  memory RVCT4: ROM 0x8002000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x1ffc
  scatter file: .\src\syscon.sct
  link misc: --datacompressor off
  group src
    ./src/: comms.cpp encoders.cpp main.cpp motors.cpp timer.cpp vectors.s opto.cpp lights.cpp mics.cpp touch.cpp i2c.cpp power.cpp analog.cpp fastmic.s table.s
  group common
    ./common/: flash.cpp
software components: CMSIS:CORE 5.1.1
